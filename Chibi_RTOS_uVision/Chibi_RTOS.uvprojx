# Keil uVision project Chibi_RTOS.uvprojx, settings and files
target SAMD21J18A (ARM-ADS)
  device: ATSAMD21J18A Microchip
  pack: Keil.SAMD21_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Chibi_RTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group LASSAT_core_func
    ./: main.c
  group Kernel
    ./: osKernel.c osKernel.h osKernel.s
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.1
